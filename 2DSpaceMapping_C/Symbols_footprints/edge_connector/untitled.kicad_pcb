# Repository AnjaDj/2D_Space_Mapping

File README.md:

Project Assignment "2D Space Mapping car with ability to move through a maze"
- obstacle detection
- avoiding obstacles
- 2D space mapping

## KiCad design 2DSpaceMapping_B/pcb_design/kicad_schematic_pcb/control_board.kicad_pcb

File 2DSpaceMapping_B/README.md:

# AUTONOMNO VOZILO - PROJEKTNI ZADATAK
Ovaj repozitorijum sadži dokumentaciju potrebnu za izradu projektnog zadataka iz predmeta Računarska elektronika/Mikrokontrolerski sistemi na Elektrotehničkom fakultetu u Banjoj Luci. Na projekatu rade tri studenta na četvrtoj godini. Cilj projekta jeste implementacija sistema za autonomnu vožnju koji može bezbijedno i efikasno upravljati vozilom. Sistem se nadograđuje na [Joy-car](https://joy-it.net/en/products/mb-joy-car) sa specificiranim zahtjevima.

# Specifikacija projektnog zadataka 
### Upravljačka PCB ploča
Potrebno je realizovati PCB pločicu koja ispunjava sljedeće zahtjeve: 
* PCB pločica može biti maksimalno dvoslojna.
* Koristi se SMD tip komponenti
* Minimalna širina veze prilikom rutiranja iznosi 0.254 mm, a minimalno rastojanje između komponenata 0.1 mm.
* Korišćenje mikrokontrolera (MCU) tipa PIC24FJ64GAxx za upravljanje i kontrolu sistema.
* Podrška za komunikaciju putem UART, SPI i I2C interfejsa za povezivanje različitih komponenti.
* Integracija Wi-Fi modula za bežičnu komunikaciju i daljinsko upravljanje.
* Upotreba već postojećeg baterijskog napajanja.
* Budzet za kupovinu komponenata od 20 do 30 dolara.

### IR Distance Click senzor
* Kretanje vozila na osnovu očitavanja senzora
* Implementacija 2D mapiranja prostora oko vozila na osnovu očivatanja senzora.

## Aplikacija
* Razvoj aplikacije za prikazivanje okoline oko vozila.
* Mogućnost pokretanja i zaustavljanja vozila putem aplikacije, 2D prikaz reljefa.
   
## Projektovanje štampane ploče
* Šema 

* Layout  

* 3D model

## Realizacija algoritma kretanja vozila

Potpuno integrisano samoupravljajuće vozilo Joy Car funkcioniše na taj način da se IR click senzor vozila najprije centrira tako da skenira prostor ispred sebe i vozilo se počinje kretati ravno, to je jedan od pet mogućih pravaca kretanja vozila. Nakon što vozilo prilikom kretanja naiđe na prepreku koja se nalazi na udaljenosti od 15cm, zaustavlja se i skenira se prostor oko vozila, tako što se okreće IR Distance Click senzor koji je postavljen na servo motoru koji se okreće za ugao od 45 stepeni u desnu stranu, odnosno lijevu. Nakon što na osnovu vrijednosti napona koju senzor generiše odredimo u kojem smjeru se prepreka nalazi najdalje, vozilo se počinje kretati u tom pravcu. Ukoliko su vrijednosti očitavanja senzora veće, tada se prepreka nalazi bliže vozilu i obratno. U slučaju da se prepreka nalazi jako blizu tada autić zbog širine točkova nije u mogućnosti da nesmetano skrene u željenom pravcu pa postoji i dodatni smijer kretanja, unazad. Tada autić najprije vozi nekoliko centimetara unazad, a zatim skrene u pravcu za koji je utvrdio da je najpovoljniji.  

Na slici ispod je prikazan primjer simulacije kretanja autića u lavirintu. 

Na gifu ispod prikazano je kretanje autića kroz lavirint:

Parts:
C1, C2, C4, C5: 100n; C1812
C3: 10u; C1812
I2C1: Conn_01x02_Pin; HDRV2W66P0X254_1X2_508X254X874P
IC1: PIC24FJ64GA002-I_SP; DIP794W56P254L3486H508Q28N; Mouser Part Number 579-PIC24FJ64GA002SP
J1: PICkit3 - ICSP; HDRV5W67P0X254_1X5_1229X234X821P
J19: Conn_01x02_Pin; HDRV2W66P0X254_1X2_508X254X874P
R1, R3, R4: 10k; RESC2012X65N
R2: 470; ERA6VK
R5, R6, R7, R8: 4.7k; ERA6AEB1020V
RST1: Conn_01x02_Pin; HDRV2W66P0X254_1X2_508X254X874P
SPI1: Conn_01x04_Pin; HDRV4W64P0X254_1X4_1016X254X889P
TP_RXD_WiFi1: Conn_01x01_Pin; SolderWire-0.1sqmm_1x01_D0.4mm_OD1mm
TP_SCL1: Conn_01x01_Pin; SolderWire-0.1sqmm_1x01_D0.4mm_OD1mm
TP_SDA1: Conn_01x01_Pin; SolderWire-0.1sqmm_1x01_D0.4mm_OD1mm
TP_TXD_WiFI1: Conn_01x01_Pin; SolderWire-0.1sqmm_1x01_D0.4mm_OD1mm
U1: Edge_Connector
UART1: Conn_01x02_Pin; HDRV2W66P0X254_1X2_508X254X874P
WiFi1: ESP8266-01_ESP-01; XCVR_ESP8266-01_ESP-01; PARTREV V1.2

Connections:
/RX: IC1.21 (PGD2/EMUD2/TDI/RP10/CN16/PMD2/RB10), UART1.1
/SCK: IC1.24 (AN11/RP13/CN13/PMRD/RB13), SPI1.2
/SCL_1: I2C1.1, IC1.17 (TCK/RP8/SCL1/CN22/PMD4/RB8), R7.2
/SDA_1: I2C1.2, IC1.18 (TDO/RP9/SDA1/CN21/PMD3/RB9), R8.2
/SDI: IC1.26 (AN9/RP15/CN11/PMCS1/RB15), SPI1.4
/SDO: IC1.25 (AN10/CVREF/RTCC/RP14/CN12/PMWR/RB14), SPI1.3
/SS: IC1.23 (AN12/RP12/CN14/PMD0/RB12), SPI1.1
/TX: IC1.22 (PGC2/EMUC2/TMS/RP11/CN15/PMD1/RB11), UART1.2
GND: C1.1, C3.2, C4.2, C5.1, IC1.8 (VSS_1), IC1.19 (DISVREG), J1.3, RST1.1, U1.24 (GND), WiFi1.1 (GND)
unnamed: IC1.6 (AN4/C1IN-/RP2/SDA2/CN6/RB2), R6.2, TP_SDA1.1, U1.22 (SDA)
unnamed: IC1.7 (AN5/C1IN+/RP3/SCL2/CN7/RB3), R5.2, TP_SCL1.1, U1.21 (SCL)
unnamed: IC1.5 (PGC1/EMUC1/AN3/C2IN+/RP1/CN5/RB1), J1.5
unnamed: IC1.15 (PGC3/EMUC3/RP6/ASCL1/CN24/PMD6/RB6), TP_TXD_WiFI1.1, WiFi1.5 (TXD)
unnamed: IC1.4 (PGD1/EMUD1/AN2/C2IN-/RP0/CN4/RB0), J1.4
unnamed: IC1.16 (RP7/INT0/CN23/PMD5/RB7), TP_RXD_WiFi1.1, WiFi1.4 (RXD)
unnamed: C3.1, IC1.20 (VCAP/VDDCORE)
unnamed: C2.2, IC1.27 (VSS_2)
unnamed: IC1.1 (~MCLR), R2.2
unnamed: J1.1, J19.2, R1.2, R2.1
unnamed: C4.1, J19.1
unnamed: R3.2, RST1.2, WiFi1.7 (~RST)
unnamed: R4.2, WiFi1.6 (EN)
VDD: C1.2, C2.1, C5.2, IC1.13 (VDD_1), IC1.28 (VDD_2), J1.2, R1.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, U1.19 (3v3), WiFi1.8 (VCC)

Notes on the sheet:
TP_12
TP_11

Board: 2 copper layers, 62.4 x 72.6 mm, 26 parts (0 on the bottom side), 23 nets.

## KiCad design 2DSpaceMapping_C/work/pcb_layout_c/pcb_layout_c.kicad_pcb

File 2DSpaceMapping_C/README.md:

# 2DSpaceMapping autonomous vehicle 🚗 ➡️ HARDWARE SIDE

This is a hardware_branch which contains models for assembly electronic devices/ modules / components. <br />
For more detailed informations about each used modul, visit Wiki 📜 page. <br />
 <br />
## Currently implemented :
  - edge connector
  - MCU PIC24FJ64GA002-I/SP
  - normally opened button TS02-66-50-BK-100-SCR-D
  - WiFi module WRL-17146
  - Slide-Switch SLW-883935-2A-D
  - 2x4 pin socket for WiFi module 5-534206-4
  - MCU socket 1-2199298-9

## Guidance through file hierarchy :
  - Symbols_footprints ➡️ contains .kicad_sym & .kicad_mod files for each used modul / component on the scheme
  - pcb ➡️  contains .png screenshots of .kicad_pcb file
  - schema ➡️  contains .png screenshots of .kicad_sch file and .pdf file exported from KiCad project
  - work ➡️  project work directory. Run ♻️ the pcb_layout_c.kicad_pro form this directory using KiCad7.0 or latest. <br /> (KiCad DOWNLOAD link 🆓⬇️ : https://www.kicad.org/download/windows/)
  - components.csv ➡️ list of used components for this project with Mouser Electronics 🐁 link to each of them. <br /> (https://hr.mouser.com/?gad_source=1&gclid=Cj0KCQiAw6yuBhDrARIsACf94RVZDfmztJkKG18F4qrYKF0iiaaEyd-j5r4cXpUXJpGI24s9JXtPty4aAuFKEALw_wcB)

## KiCad Schema : 

## KiCad PCB Layout: 

## KiCad 3D View PCB :

## Guidance through Git Bash commands :
1. 		git checkout hardware_branch
2. 		git pull origin hardware_branch
3. 🚧 ...modification... 🚧
4. 		git add .
5. 		git commit -m "Issue#n
   		- Line1
   		- Line2
   		- ..."
     n  - the number of Issue being worked on
7. 		git push origin hardware_branch

Board: 2 copper layers, 51.6 x 55.9 mm, 15 parts (0 on the bottom side), 22 nets.

Parts:
C1, C2, C3: 0.1uF; CAPC1608X95N
C4: 10uF; CAPC3225X210N
J1: Conn_01x15_Pin; PinHeader_1x15_P2.54mm_Vertical
MCU_RST: TS02-66-50-BK-100-SCR-D; TS026650BK100SCRD
OP/PROG: SLW-883935-2A-D; SLW8839352AD
PIC24FJ64GA002: 2024-01-28_16-23-25_PIC24FJ64GA002-X_SP; DIP762W60P254L3556H510Q28
R1, R3, R4: 10K; RESC3216X60N
R2: 250; RESC3216X70N
WIFI: 5-534206-4; RHDR8W69P254_2X4_1016X503X877P
WIFI_RST: TS02-66-50-BK-100-SCR-D; TS026650BK100SCRD
edge_connector1: edge_connector1; BBC_EDGE

Connections:
BAT_CONN: J1.10, PIC24FJ64GA002.2 (AN0/VREF+/CN2/RA0)
GND: C1.1, C2.2, C3.2, C4.2, J1.3, J1.11, MCU_RST.1 (NO_1), MCU_RST.2 (NO_2), PIC24FJ64GA002.8 (VSS), PIC24FJ64GA002.27 (VSS), WIFI.3, WIFI.5, WIFI.7, WIFI_RST.1 (NO_1), WIFI_RST.2 (NO_2), edge_connector1.P$35 (EDGE_GND_1), edge_connector1.P$36 (EDGE_GND_2), edge_connector1.P$37 (EDGE_GND_3), edge_connector1.P$38 (EDGE_GND_4), edge_connector1.P$39 (EDGE_GND_5), edge_connector1.P$40 (EDGE_GND_16)
MCLR: J1.14, OP/PROG.3 (NO), R3.1
unnamed: C3.1, R1.1, R2.1
unnamed: OP/PROG.2 (COM), PIC24FJ64GA002.1 (*MCLR)
unnamed: PIC24FJ64GA002.17 (TCK/RP8/SCL1/CN22/PMD4/RB8), edge_connector1.P$33 (EDGE_P19)
unnamed: PIC24FJ64GA002.18 (TDO/RP9/SDA1/CN21/PMD3/RB9), edge_connector1.P$34 (EDGE_P20)
unnamed: C4.1, PIC24FJ64GA002.20 (VCAP/VDDCORE)
unnamed: MCU_RST.3 (COM_1), MCU_RST.4 (COM_2), OP/PROG.1 (NC), R2.2
unnamed: R4.2, WIFI.4, WIFI_RST.3 (COM_1), WIFI_RST.4 (COM_2)
PGC1: J1.13, PIC24FJ64GA002.5 (PGC1/EMUC1/AN3/C2IN+/RP1/CN5/RB1)
PGD1: J1.12, PIC24FJ64GA002.4 (PGD1/EMUD1/AN2/C2IN-/RP0/CN4/RB0)
RX: J1.1, PIC24FJ64GA002.15 (PGC3/EMUC3/RP6/ASCL1/CN24/PMD6/RB6)
RX input: PIC24FJ64GA002.21 (PGD2/EMUD2/TDI/RP10/CN16/PMD2/RB10), WIFI.1
SCL2: J1.9, PIC24FJ64GA002.7 (AN5/C1IN+/RP3/SCL2/CN7/RB3)
SDA2: J1.8, PIC24FJ64GA002.6 (AN4/C1IN-/RP2/SDA2/CN6/RB2)
SPI1 Clock Output: J1.6, PIC24FJ64GA002.24 (AN11/RP13/CN13/PMRD/RB13)
SPI1 Data Output: J1.7, PIC24FJ64GA002.25 (AN10/CVREF/RTCC/RP14/CN12/PMWR/RB14)
SPI1 Slave Select Output: J1.5, PIC24FJ64GA002.23 (AN12/RP12/CN14/PMD0/RB12)
TX: J1.2, PIC24FJ64GA002.16 (RP7/INT0/CN23/PMD5/RB7)
TX out: PIC24FJ64GA002.26 (AN9/RP15/CN11/PMCS1/RB15), WIFI.8
VDD: C1.2, C2.1, J1.4, J1.15, PIC24FJ64GA002.13 (VDD), PIC24FJ64GA002.28 (VDD), R1.2, R3.2, R4.1, WIFI.2, WIFI.6, edge_connector1.P$27 (EDGE_3V3_1), edge_connector1.P$28 (EDGE_3V3_2), edge_connector1.P$29 (EDGE_3V3_3), edge_connector1.P$30 (EDGE_3V3_4), edge_connector1.P$31 (EDGE_3V3_5), edge_connector1.P$32 (EDGE_3V3_6)

## Commit log

2024-08-02 Dodavanje rjesenja projekta grupa A,B,C
